# Keil uVision project stm32l0Lora.uvprojx, settings and files
target version4.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZEx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: stm32l0Lora
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32L072xx
  c include: .\CMSIS;.\ecrypt;.\loraLib;.\universal;.\user;.\regLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./user/: main.c interrupt.c loraApp.c
  group CMSIS
    ./CMSIS/: startup_stm32l072xx.s system_stm32l0xx.c
  group HARDWARE
    ./regLib/: clock.c delay.c gpio.c spi.c usart.c lowpower.c rtc.c rng.c interrupt.c
  group LORA
    ./loraLib/: lora.c loraChip.c
    ./ecrypt/: aes.c cmac.c LoRaMacCrypto.c
  group OTHERS
    ./universal/: universal.c
